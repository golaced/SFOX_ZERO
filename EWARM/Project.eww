<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SFOX_ZERO.ewp</path>
  </project>
  <batchBuild />
</workspace>
